# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,
  c misc: --diag_suppress=1,177,550
  c include: ..\CMSIS;..\DEVICE_LIB\inc;..\SYSTEM;..\USER;..\HARDWARE;..\HARDWARE;..\APPLICATION;..\APPLICATION\MFRC522;..\APPLICATION\W25QXX;..\APPLICATION\AT24CXX;..\APPLICATION\BUTTON;..\APPLICATION\OLED(0.96);..\APPLICATION\AD9833;..\APPLICATION\AD7746
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APPLICATION
    ../APPLICATION/MFRC522/: mfrc522.c
    ../APPLICATION/W25QXX/: w25qxx.c
    ../APPLICATION/AT24CXX/: at24cxx.c
    ../APPLICATION/BUTTON/: button.c
    ../APPLICATION/OLED(0.96)/: OLED_Data.c OLED.c OLED_Menu.c
    ../APPLICATION/AD9833/: ad9833.c
    ../APPLICATION/AD7746/: ad7746.c
  group HARDWARE
    ../HARDWARE/: base_timer.c pwm.c led.c uart.c sonic.c dht11.c iwdg.c wwdg.c gtimer.c rtc.c flash.c adc.c hspi.c jack_i2c.c key.c
  group USER
    ./: main.c stm32f4xx_it.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_flash.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_i2c.c
  group SYSTEM
    ../SYSTEM/: system_stm32f4xx.c delay.c
  group README
    ../: Readme.txt
